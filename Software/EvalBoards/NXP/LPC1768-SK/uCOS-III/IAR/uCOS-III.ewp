# IAR project uCOS-III.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\uCOS-III; ..\..\BSP; ..\..\BSP\IAR; ..\..\BSP\OS\uCOS-III; ..\..\..\..\..\uC-CSP\MCU\; ..\..\..\..\..\uC-CSP\MCU\NXP\LPC17xx\LPC1768; ..\..\..\..\..\uC-CSP\MCU\NXP\LPC17xx; ..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M3\CSP; ..\..\..\..\..\uCOS-III\Source; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\uC-MB\Source; ..\..\..\..\..\uC-MB\Cfg\Template; ..\..\..\..\..\uC-MB\Os\uCOS-III; ..\..\..\..\..\OSAL\OS; ..\..\..\..\..\OSAL\Ports; ..\..\..\..\..\APP\User; ..\..\..\..\..\APP\Iap; ..\..\..\..\..\APP\Protocol; ..\..\..\..\..\APP\Tasks; ..\..\..\..\..\APP\AES; ..\..\..\..\..\BSP\OS\OSAL; ..\..\..\..\..\CSB\include; ..\..\..\..\..\BSP\Driver; ..\..\..\..\..\..\Application; ..\..\..\..\..\..\Application\User; ..\..\..\..\..\..\Application\User\APP; ..\..\..\..\..\..\Application\User\APP\MX25L1602Drv; ..\..\..\..\..\..\Application\User\APP\OCM800600T80; ..\..\..\..\..\..\Application\User\BSP; ..\..\..\..\..\..\Application\Library\CardOperations; ..\..\..\..\..\..\Application\Library\DataDeal; ..\..\..\..\..\..\Application\Library\Driver; ..\..\..\..\..\..\Application\Library\EquipmentOperations; ..\..\..\..\..\..\Application\Library\Global; ..\..\..\..\..\..\Application\Library\MastConTask; ..\..\..\..\..\..\Application\Library\SlaveConTask; ..\..\..\..\..\..\Application\Library\SpeedTest; ..\..\..\..\..\..\Application\Library\csnr_package_deal; ..\..\..\..\..\..\Application\Library\iap; ..\..\..\..\..\..\Application\Library\tax
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: F:\iar\NC136B-310 统计模块\Application\Library
  OBJCOPY.OOCOutputFile: uCOS-III.bin
  ILINK.IlinkOutputFile: uCOS-III-TCPIP-V2.out
  ILINK.IlinkIcfFile: F:\embedsoft\Micrium_LPC1768-SK_uCOS-III\Software\EvalBoards\NXP\LPC1768-SK\BSP\IAR\LPC1768_FLASH512K_SRAM32K.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../../../../../embedsoft/Micrium_LPC1768-SK_uCOS-III/Software/EvalBoards/NXP/LPC1768-SK/BSP/IAR/: LPC1768_FLASH512K_SRAM32K.icf
  group APP/APP
    ../../../../../APP/comm/: app_comm_dtu.c app_comm_dtu_otr_deal.c app_comm_mtr.c app_comm_otr.c app_comm_tax.c
    ../../../../../APP/Protocol/: app_comm_protocol.c
    ../../../../../APP/User/: app_lib.c sprintf.c xapp.c
    ../../../../../APP/Tasks/: app_task_comm.c app_task_osal.c APP_task_osal_Calc.c app_task_osal_disp.c app_task_osal_led.c app_task_osal_speed.c APP_task_osal_store.c app_task_osal_tmr.c
    ../../../../../../Application/Library/iap/: IAP_program_mcu.C
    ../../../../../APP/: xmain.c
  group APP/BSP
    ../../../../../BSP/Driver/: bsp_FRAM.c bsp_FRAM.h bsp_gpio.c bsp_IIC.c bsp_IIC.h bsp_lpc_timer.c
  group APP/LIB
    ../../../../../../Application/User/BSP/: system_LPC17xx.c
    ../../../../../../Application/User/: tmp.c
  group APP/LIB/CardOperations
    ../../../../../../Application/Library/CardOperations/: Card.c Card.h CardTest.c CardTest.h DataCard.c DataCard.h OperateCard.c OperateCard.h ParaCard.c ParaCard.h
  group APP/LIB/csnr_package_deal
    ../../../../../../Application/Library/csnr_package_deal/: csnc_package_deal.c
  group APP/LIB/DataDeal
    ../../../../../../Application/Library/DataDeal/: DealOilBox.c DealOilBox.h RecModel.c RecModel.h
  group APP/LIB/Driver
    ../../../../../../Application/Library/Driver/: ADC.c ADC.h Display.c Display.h DS3231.c DS3231.h Led.c Led.h MX25L1602Drv.c MX25L1602Drv.h SoftSpi_17xx.c WatchDog.C WatchDog.h
  group APP/LIB/EquipmentOperations
    ../../../../../../Application/Library/EquipmentOperations/: EquimentCom.c EquimentOperate.c
  group APP/LIB/Global
    ../../../../../../Application/Library/Global/: CardDataTypeDef.h CrcCheck.c CrcCheck.h DataTypeDef.h FIFO.c FIFO.h GlobePara.c GlobePara.h IdDataTypeDef.h LocoModTypeDef.h RecDataTypeDef.h
  group APP/LIB/MastConTask
    ../../../../../../Application/Library/MastConTask/: DipComOperate.c GetDipPrs.c GetDipPrs.h power.c power.h
  group APP/LIB/SlaveConTask
    ../../../../../../Application/Library/SlaveConTask/: cnsccomdeal.c cnscpackdeal.c csnr.c csnr_package_deal.h
  group APP/LIB/SpeedTest
    ../../../../../../Application/Library/SpeedTest/: locoworksta.C mstcsspeed.C speed1.C speed2.C
  group APP/LIB/tax
    ../../../../../../Application/Library/tax/: app_tax.c app_tax.h
  group APP/uC/MB/Cfg
    ../../../../../uC-MB/Cfg/Template/: mb_app_hooks.c mb_app_hooks.h mb_cfg.h MB_DATA.C
  group APP/uC/MB/OS/uCOS-III
    ../../../../../uC-MB/OS/uCOS-III/: MB_OS.C MB_OS.H
  group APP/uC/MB/Ports/NXP
    ../../../../../uC-MB/Ports/NXP/LPC1768/IAR/: MB_BSP.C
  group APP/uC/MB/Source
    ../../../../../uC-MB/Source/: MB.C mb.h MB_AES.C MB_DEF.H MB_UTIL.C MBM_CORE.C MBS_CORE.C
  group BSP
    ./: core_cm3.h core_cmFunc.h core_cmInstr.h
  group BSP/CSB
    ./: lpc17xx.h system_LPC17xx.h
  group BSP/CSB/Inc
    ../../../../../CSB/include/: debug_frmwrk.h lpc17xx_adc.h lpc17xx_can.h lpc17xx_clkpwr.h lpc17xx_dac.h lpc17xx_emac.h lpc17xx_exti.h lpc17xx_gpdma.h lpc17xx_gpio.h lpc17xx_i2c.h lpc17xx_i2s.h lpc17xx_iap.h lpc17xx_libcfg_default.h lpc17xx_mcpwm.h lpc17xx_nvic.h lpc17xx_pinsel.h lpc17xx_pwm.h lpc17xx_qei.h lpc17xx_rit.h lpc17xx_rtc.h lpc17xx_spi.h lpc17xx_ssp.h lpc17xx_systick.h lpc17xx_timer.h lpc17xx_uart.h lpc17xx_wdt.h lpc_types.h
  group BSP/CSB/Src
    ../../../../../CSB/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_iap.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c makefile
  group BSP/Driver/Board
    ../../../../../BSP/Driver/: bsp_max7219.c bsp_max7219.h
  group BSP/OS/OSAL
    ../../../../../BSP/OS/OSAL/: bsp_hal.c bsp_hal.h bsp_timer.c bsp_timer.h
  group BSP/OSAL/OS
    ../../../../../OSAL/OS/: osal.c osal.h osal_cpu.h osal_event.c osal_event.h osal_memory.c osal_memory.h osal_timer.c osal_timer.h
  group text
    ../../../../../APP/User/: readme.md
  group uC/OS-III/APP
    ../: app.c app_hooks.c cpu_cfg.h csp_cfg.h includes.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
    ./: app_cfg.h
  group uC/OS-III/BSP
    ../../BSP/: bsp.c bsp.h
    ../../BSP/IAR/: cstartup.c LPC1768_FLASH512K_SRAM32K.icf
  group uC/OS-III/BSP/OS
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group uC/OS-III/uC/CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/OS-III/uC/CPU/ARM-Cortex-M3/IAR
    ../../../../../uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/OS-III/uC/CSP/MCU
    ../../../../../uC-CSP/MCU/: csp.c csp.h csp_types.h
  group uC/OS-III/uC/CSP/MCU/NXP/LPC17xx
    ../../../../../uC-CSP/MCU/NXP/LPC17xx/: csp_gpio.c csp_grp.h csp_int.c csp_pm.c csp_tmr.c
  group uC/OS-III/uC/CSP/MCU/NXP/LPC17xx/LPC1768
    ../../../../../uC-CSP/MCU/NXP/LPC17xx/LPC1768/: csp_dev.h
  group uC/OS-III/uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-III/uC/LIB/Ports/ARM-Cortex-M3/IAR
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-III/uC/OS-III/Port/ARM-Cortex-M3/CSP
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/CSP/: os_csp.h
  group uC/OS-III/uC/OS-III/Port/ARM-Cortex-M3/CSP/Generic
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/CSP/Generic/: os_csp.c
  group uC/OS-III/uC/OS-III/Port/ARM-Cortex-M3/Generic/IAR
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/uC/OS-III/Source
    ../../../../../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
